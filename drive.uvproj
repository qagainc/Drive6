# Keil uVision project drive.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ADS1262 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\adsH;.\ADS126x
  group Source Group 1
    ./src/: main.c CRC16.c RS485.c
    ./adsH/: initt.c
